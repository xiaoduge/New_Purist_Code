# Keil uVision project UCOS.uvprojx, settings and files
target RAM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: 0860210008WDMB_Main_V_1_0 +hex
  c flags: Optim=4 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,CAN_ADR_FILTER,USE_USART1_STDIO,CCEA,xIAP,xSHOW_TIME
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\FWLIB\inc;..\uCOS-II\Ports;..\uCOS-II\Source;..\uCOS-II\uC-CPU;..\uCOS-II\uC-LIB;..\Utilities\VOS;..\BSP;..\Utilities\Driver\STM32F4xx_HAL_Driver\Inc;..\MALLOC;..\SYSTEM\sys;..\LWIP;..\LWIP\arch;..\LWIP\lwip-1.4.1\src\include;..\LWIP\lwip-1.4.1\src\api;..\LWIP\lwip-1.4.1\src\core;..\LWIP\lwip-1.4.1\src\netif;..\LWIP\lwip-1.4.1\src\include\ipv4\lwip;..\LWIP\lwip-1.4.1\src\include\ipv4;..\LWIP\lwip-1.4.1\src\include\netif;..\LWIP\lwip_app\lwip_comm;..\BSP\SDIO;..\FATFS\src
  asm define: __FPU_PRESENT=1,__FPU_USED=1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: ..\stm32f4xx_norm.sct
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c Beep.c DICA.c Relay.c Printf.c UartCmd.c config.c list.c serial.c display.c AT.C modbus.c LCD.c storage.c ble.c tocData.c
    ../font/: font.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_flash.c stm32f4xx_i2c.c stm32f4xx_pwr.c stm32f4xx_rtc.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_iwdg.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_sdio.c
  group README
    ../: readme.txt
  group BSP
    ../BSP/: OSAL_Memory.c
  group LIB
    ../LIB/: STM32F4xxlib.lib 0860210008WDMBUSERLIB.lib
